# Keil uVision project 维度匹配.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\User;..\System;..\Satrt;..\Libarary;..\System\delay;..\System\sys;..\System\usart;..\Hardware;..\DSP_Lib;..\TouchScreen;..\AD7606;..\DSP_Lib\Include;..\OS;..\Peripheral
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Start
    ../Satrt/: startup_stm32f40_41xxx.s
  group User
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx.h main.h
  group Library
    ../Libarary/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_dma2d.c stm32f4xx_dma2d.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_ltdc.c stm32f4xx_ltdc.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sai.c stm32f4xx_sai.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group System
    ../System/sys/: sys.c
    ../System/: NVIC.c Kalman.c Kalman.h FFT.c FFT.h
    ../System/delay/: delay.h delay.c
  group Hardware
    ../Hardware/: ADC.c ADC.h Cmd.c Cmd.h hcsr04.c hcsr04.h NTC.c NTC.h pwm.c pwm.h Rtc.c Rtc.h uart.c uart.h Time.c Time.h Task.c Task.h DAC.c DAC.h
  group DSP_Lib
    ../DSP_Lib/: arm_cortexM4lf_math.lib
  group TouchScreen
    ../TouchScreen/: cmd_process.c cmd_process.h cmd_queue.c cmd_queue.h hmi_driver.c hmi_driver.h
  group AD7606
    ../AD7606/: AD7606.c AD7606.h byyc_gpio.c byyc_gpio.h byyc_spi.c byyc_spi.h byyc_dma.c byyc_dma.h
  group OS
    ../OS/: Proc.c Proc.h OS_Task.c OS_Task.h Excel.c Excel.h
  group Peripheral
    ../Peripheral/: Steering.c Steering.h
